# IAR project projeto.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: PART_TM4C1294NCPDT; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\drivers; ..\..\TivaWare_C_Series-2.1.4.178; ..\..\CMSIS-5.6.0\CMSIS\Core\Include; ..\..\CMSIS-5.6.0\CMSIS\RTOS2\Include; ..\..\CMSIS-5.6.0\CMSIS\RTOS2\RTX\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..\..
  OBJCOPY.OOCOutputFile: projeto.bin
  ILINK.IlinkOutputFile: tarefas.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    $EW_DIR$/EK-TM4C1294_RTOS_IAR8-master/TivaWare_C_Series-2.1.4.178/driverlib/ewarm/Exe/: driverlib.a
    $EW_DIR$/EK-TM4C1294_RTOS_IAR8-master/CMSIS-5.6.0/CMSIS/RTOS2/RTX/Library/IAR/IDE/CM4F/Exe/: RTX_CM.a
    src/: RTX_Config.c rtx_lib.c startup_TM4C1294.s system_TM4C1294_TW.c tarefas.c UARTInit.c UARTInit.h uartstdio.c uartstdio.h
    $EW_DIR$/EK-TM4C1294_RTOS_IAR8-master/CMSIS-5.6.0/CMSIS/RTOS2/RTX/Config/: RTX_Config.h
    $EW_DIR$/EK-TM4C1294_RTOS_IAR8-master/TivaWare_C_Series-2.1.4.178/driverlib/: uart.c uart.h
